# Copyright (C) 2019, STMicroelectronics - All Rights Reserved

SUMMARY = "Increasing rootfs partition and enabling kernel module"

ROOTFS_PARTITION_SIZE = "1232896"

CORE_IMAGE_EXTRA_INSTALL += "rpmsg-sdb-mod"